## base_external/package/ldd/Config.in
```kconfig
depends on BR2_LINUX_KERNEL

config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes ldd stuff, idk yet
```
